# Repository Robomaster-Group-2/RM2025-Internal-Template

File README.md:

# RM2025-Internal-Template

This is the template project for RM2025 Internal competition.

## Quick start guide

To use this template, clone the template in your terminal with:

```bash
git clone git@github.com:hkustenterprize/RM2025-Internal-Template.git
```

enter the directory with:

```bash
cd RM2025-Internal-Template
```

compile with Makefile

```bash
make -j
```

## Structure

- The directory `./Drivers` and `./Middlewares` contains the HAL drivers generated by CubeMX, you may ignore them.
- The directory `./RM2025-Internal-Core` contains the drivers. You may ignore the FreeRTOS and diagnostic directories as we have already set them up for you.
- You have to implement your own drivers, such as rc or motors driver in `./RM2025-Internal-Core\Drivers`
- You may use the drivers in the Core directory developed by you and implement applications of the tasks in `./Core\Src` and `./Core\Inc`
- Within `./Core/Inc/AppConfig.h`, you could enable/disable certain drivers and configure them. Port configurations had been configured according to the Internal board design.
- Tasks are created in `./Core/Src/UserTask.cpp`. You may set initializing code here
- Most of your code may happen in `./RM2025-Internal-Core/Drivers` and `./Core/Src`.

Wish good luck.

## KiCad design Hardware/Internal.kicad_pcb

Parts:
BZ1: Buzzer; MLT-9032
C1, C4, C5, C7, C8, C9, C11, C15, C18, C22, C23, C24, C25, C31: 100nF; C_0603_1608Metric
C2, C3, C10, C14, C19, C27: 20pF; C_0603_1608Metric
C6, C26: 4.7uF; C_0603_1608Metric
C12: 10nF; C_0603_1608Metric
C13, C28: 10uF; C_0603_1608Metric
C16, C17, C20, C21, C29, C30: 10uF; C_1206_3216Metric
D1: TVS 3.3V; D_SMF
D2, D9, D11: K34; D_SMF
D3, D6, D10, D13, D14, D15, D16, D17, D18, D19, D20: LED_BLUE; LED_0603_1608Metric
D4, D5: LED_RED; LED_0603_1608Metric
D7: SMCJ28A; D_SMC
D8: NUP2105L; SOT-23
D12: SMAJ5.0A; D_SMA
F1, F2, F3: 0.5A; Fuse_1206_3216Metric
F4: 20A; 1808_Fuse
J1: SWD; Molex_PicoBlade_53398-0471_1x04-1MP_P1.25mm_Vertical
J2, J5, J15, J16, J17, J18, J19, J20: CAN; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12_NO_HOLE
J4: JLINK_SWD; Molex_PicoBlade_53047-0410_1x04_P1.25mm_Vertical
J6: 24V_IN; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J7, J8, J9, J10, J11, J12, J13, J14: 24V_OUT; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J21: DR16; PinHeader_1x03_P2.54mm_Vertical
J22, J23, J24: 2.54; PinSocket_1x04_P2.54mm_Vertical
L1: 4.7uH; L_Cenker_CKCS4020
Q1: S8050; SOT-23
Q2, Q3: AO3400A; SOT-23
R1, R2, R3, R4: 33; R_0402_1005Metric
R5, R32, R34: 120; R_0603_1608Metric
R6: 10K; R_0402_1005Metric
R7, R8: 5.1K; R_0402_1005Metric
R9: 1.5K; R_0603_1608Metric
R10, R16, R18, R19, R20, R21, R23, R24, R28, R33, R37, R40: 10K; R_0603_1608Metric
R11: 33K; R_0603_1608Metric
R12, R22: 100; R_0603_1608Metric
R13: 1M; R_0603_1608Metric
R14, R15, R26, R27: 33; R_0603_1608Metric
R17, R35: 100K; R_0603_1608Metric
R25, R39, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58: 1K; R_0603_1608Metric
R29: 53.6k; R_0603_1608Metric
R30: 10k; R_0603_1608Metric
R31: 4.7K; R_0603_1608Metric
R36, R38, R41: 330; R_0603_1608Metric
RN1: 82R; R_Array_Concave_4x0603
SW1: BTN1; SW_SPST_PTS810
SW2: RST; SW_SPST_PTS810
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
U1: STM32G431CBUx; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm
U2: SIT1042T/3; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32F103CBT6; LQFP-48_7x7mm_P0.5mm
U4: RS3236; SOT-23-5
U5: RY8411; SOT-23-6
U7: D1X8K-14BL; D1X8K
Y1, Y3: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: R33.1, SW1.2
+3V3: C1.2, C4.2, C5.2, C6.2, C7.2, C13.1, C23.2, C24.2, C25.2, C26.2, D1.1 (A1), D2.2 (A), F1.1, J4.4, Q1.3 (C), R6.2, R17.2, R21.2, R23.2, R25.2, R31.1, U1.1 (VBAT), U1.20 (VREF+), U1.21 (VDDA), U1.23 (VDD), U1.35 (VDD), U1.48 (VDD), U2.5 (VIO), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.5 (OUT)
+5V: BZ1.2 (+), C11.1, C19.1, C20.1, C21.1, C27.1, C28.1, C29.1, C30.1, C31.2, D2.1 (K), D9.1 (K), D11.1 (K), D12.1 (A1), J21.2, J23.1, J23.2, J23.3, J23.4, L1.2, R10.1, R29.1, U2.3 (VCC), U4.1 (IN), U4.3 (EN)
+5V_USB: D11.2 (A), F2.1
+24V: R28.1
+24V_IN: D7.1 (A1), F3.2, F4.1, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2
BTN0: C22.1, R36.1
BUZZER: R40.1, R41.1, U1.29 (PC6)
CAN_H: D8.2 (K), J2.2, J5.2, J15.2, J16.2, J17.2, J18.2, J19.2, J20.2, R5.1, U2.7 (CANH)
CAN_L: D8.1 (K), J2.1, J5.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, R5.2, U2.6 (CANL)
CAN_RX: R4.2, U1.33 (PA11)
CAN_TX: R3.2, U1.34 (PA12)
D+: R14.2, U3.33 (PA12)
D-: R15.2, U3.32 (PA11)
DR16_RX: R32.1, U1.24 (PB11)
F103_SWCLK: J4.2, U3.37 (PA14)
F103_SWDIO: J4.1, U3.34 (PA13)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.1, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.1, C26.1, C28.2, C29.2, C30.2, C31.1, D1.2 (A2), D4.1 (K), D5.1 (K), D6.1 (K), D7.2 (A2), D8.3 (A), D10.1 (K), D12.2 (A2), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), J1.3, J1.MP (MountPin), J2.MP (MountPin), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J4.3, J5.MP (MountPin), J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.MP (MountPin), J16.MP (MountPin), J17.MP (MountPin), J18.MP (MountPin), J19.MP (MountPin), J20.MP (MountPin), J21.3, J24.1, J24.2, J24.3, J24.4, Q2.2 (S), Q3.2 (S), R7.1, R8.1, R11.2, R13.1, R18.2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
JLINK_SWCLK: R27.1, U3.15 (PA5), U3.26 (PB13)
JLINK_SWDIO: R22.2, R26.1, U3.27 (PB14)
LED0: R39.2
LED1: R42.2
LED_STLINK: D3.1 (K), U3.30 (PA9)
unnamed: BZ1.1 (-), C27.2, D9.2 (A), Q3.3 (D)
unnamed: C9.1, R16.2, R17.1
unnamed: D3.2 (A), R25.1
unnamed: D4.2 (A), R28.2
unnamed: D5.2 (A), R31.2
unnamed: D6.2 (A), R39.1
unnamed: D10.2 (A), R42.1
unnamed: D13.2 (A), R51.2
unnamed: D14.2 (A), R52.2
unnamed: D15.2 (A), R53.2
unnamed: D16.2 (A), R54.2
unnamed: D17.2 (A), R55.2
unnamed: D18.2 (A), R56.2
unnamed: D19.2 (A), R57.2
unnamed: D20.2 (A), R58.2
unnamed: F2.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
unnamed: J1.1, R1.2
unnamed: J1.2, R2.2
unnamed: F1.2, J1.4
unnamed: J3.A5 (CC1), R7.2
unnamed: J3.B5 (CC2), R8.2
unnamed: J3.A6 (D+), J3.B6 (D+), R9.2, R14.1
unnamed: J3.A7 (D-), J3.B7 (D-), R15.1
unnamed: C8.2, J3.S1 (SHIELD), R13.2
unnamed: F4.2, J6.2
unnamed: J21.1, R34.2, R35.1
unnamed: J22.1, RN1.8 (R1.2)
unnamed: J22.2, RN1.7 (R2.2)
unnamed: J22.3, RN1.6 (R3.2)
unnamed: J22.4, RN1.5 (R4.2)
unnamed: Q1.1 (B), R10.2, R11.1, R12.1
unnamed: Q1.2 (E), R9.1
unnamed: Q2.3 (D), R32.2, R33.2
unnamed: Q2.1 (G), R34.1
unnamed: Q3.1 (G), R41.2
unnamed: R36.2, R37.1, SW1.1
unnamed: R38.2, SW2.1
unnamed: C2.2, U1.5 (PF0), Y1.3
unnamed: C3.2, U1.6 (PF1), Y1.1
unnamed: R4.1, U2.4 (RXD)
unnamed: R3.1, U2.1 (TXD)
unnamed: R18.1, U3.44 (BOOT0)
unnamed: R16.1, U3.7 (NRST)
unnamed: R23.1, R24.2, U3.10 (PA0)
unnamed: R21.1, U3.39 (PB3)
unnamed: R22.1, U3.25 (PB12)
unnamed: R19.1, U3.2 (PC13)
unnamed: R20.1, U3.3 (PC14)
unnamed: C10.2, U3.5 (PD0), Y3.1
unnamed: C14.2, U3.6 (PD1), Y3.3
unnamed: C12.1, U4.4 (BP)
unnamed: C18.1, U5.1 (BS)
unnamed: C16.1, C17.1, F3.1, U5.4 (EN), U5.5 (IN)
unnamed: C19.2, R29.2, R30.1, U5.3 (FB)
unnamed: C18.2, L1.1, U5.6 (LX)
unnamed: R43.2, U7.7 (A)
unnamed: R44.2, U7.6 (B)
unnamed: R45.2, U7.4 (C)
unnamed: R46.2, U7.2 (D)
unnamed: R50.2, U7.5 (DP)
unnamed: R47.2, U7.1 (E)
unnamed: R48.2, U7.9 (F)
unnamed: R49.2, U7.10 (G)
PA0: R43.1, R51.1, TP1.1
PA1: R44.1, R52.1, TP2.1
PA2: R45.1, R53.1, TP3.1
PA3: R46.1, R54.1, TP4.1
PA4: R47.1, R55.1, TP5.1
PA5: R48.1, R56.1, TP6.1
PA6: R49.1, R57.1, TP7.1
PA7: R50.1, R58.1, TP8.1
PB4: RN1.1 (R1.1), U1.42 (PB4)
PB5: RN1.2 (R2.1), U1.43 (PB5)
PB6: RN1.3 (R3.1), U1.44 (PB6)
PB7: RN1.4 (R4.1), U1.45 (PB7)
RST: C15.1, R6.1, R38.1, U1.7 (PG10)
SWCLK: R2.1, R27.2, U1.37 (PA14)
SWDIO: R1.1, R26.2, U1.36 (PA13)
USB_RNUM: R12.2, U3.38 (PA15)

Notes on the sheet:
2.54排针
BUZZER
USB-JLink
POWER
BTN/LED
DR16
CAN
MCU

Board: 2 copper layers, 161 parts (8 on the bottom side), 99 nets, no tracks yet.

## Commit log

2024-08-09 Add Hardware Design
2024-08-09 update IOC
2024-08-09 Add Internal Core
    Add CPP compile support;
    FreeROTS support;
    System View support;
    FPU support;
    Add RM2023 Internal Core
2024-08-10 fix pcb bug
2024-08-10 update PCB
2024-08-31 sync hardware design
2024-08-31 move file
2024-09-02 WS2812 Driver
2024-09-02 update WS2812 Driver
2024-09-19 static libraries restore, clock configurations restore
2024-09-19 add gitignore back
2024-10-21 update rtos kernel file
2024-10-27 Remote driver in UserTask.cpp
2024-10-27 rc driver
